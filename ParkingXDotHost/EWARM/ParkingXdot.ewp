# IAR project ParkingXdot.ewp, settings and files
configuration ParkingXdot (ARM, debug)
  General.OGChipSelectEditMenu: STM32L073RZ ST STM32L073RZ
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L073xx; USE_RTI_XDOT_PARKING_MODULE
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32L0xx_HAL_Driver/Inc; ../Drivers/STM32L0xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32L0xx/Include; ../Drivers/CMSIS/Include; ..\Middlewares\pni\SENtral-A2; ..\Middlewares\pni\system; ..\Middlewares\pni\Lora; ..\Middlewares\pni\Sensors; ..\Middlewares\ST\STM32_BlueNRG\SimpleBlueNRG_HCI\includes; ..\Middlewares\pni\FOTA; ..\Middlewares\ST\SPI_Flash; ..\Drivers\X-NUCLEO-IDB04A1; ..\Drivers\PNI_HW; ..\Middlewares\PNI\radio; ..\Middlewares\PNI\radio\xdot; ..\Middlewares\PNI\system\crypto; ..\Middlewares\PNI\parking; ..\Drivers\MCP9808; ..\Middlewares\PNI\parking\temperature; ..\Middlewares\PNI\radio\xdot\ch; ..\Middlewares\PNI\radio\xdot\us
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ParkingXdot.bin
  ILINK.IlinkOutputFile: ParkingXdot.out
  ILINK.IlinkIcfFile: stm32l073xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32l073xx.s
  group Application/User
    ../Src/: adc.c clock.c crc.c dma.c gpio.c i2c.c lptim.c main.c rtc.c spi.c stm32l0xx_hal_msp.c stm32l0xx_it.c usart.c wwdg.c
  group Drivers/BLE_MODULE
    ../Drivers/X-NUCLEO-IDB04A1/: stm32_bluenrg_ble.c
  group Drivers/CMSIS
    ../Src/: system_stm32l0xx.c
  group Drivers/MCP9808
    ../Drivers/MCP9808/: mcp9808.c mcp9808.h
  group Drivers/STM32L0xx_HAL_Driver
    ../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal.c stm32l0xx_hal_adc.c stm32l0xx_hal_adc_ex.c stm32l0xx_hal_cortex.c stm32l0xx_hal_crc.c stm32l0xx_hal_crc_ex.c stm32l0xx_hal_dma.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_gpio.c stm32l0xx_hal_i2c.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_lptim.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_rtc.c stm32l0xx_hal_rtc_ex.c stm32l0xx_hal_spi.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal_uart.c stm32l0xx_hal_uart_ex.c stm32l0xx_hal_wwdg.c
  group Middlewares/PNI/FOTA
    ../Middlewares/PNI/FOTA/: pni_fota.c
  group Middlewares/PNI/parking
    ../Middlewares/PNI/parking/: parking_buffer.c parking_buffer.h parking_fsm.c parking_fsm.h parking_module.c parking_module.h parking_sensor.h parking_sensor_rti.c parking_sensor_rti.h parking_types.h
  group Middlewares/PNI/parking/temperature
    ../Middlewares/PNI/parking/temperature/: park_temp_sns.h park_temp_sns_mcp9808.c park_temp_sns_mcp9808.h
  group Middlewares/PNI/radio
    ../Middlewares/PNI/radio/: radio.h
  group Middlewares/PNI/radio/xdot/ch
    ../Middlewares/PNI/radio/xdot/ch/: xdot.c xdot.h xdot_at_cmd.c xdot_at_cmd.h xdot_at_resp.c xdot_at_resp.h xdot_hex.c xdot_hex.h
  group Middlewares/PNI/radio/xdot/us
    ../Middlewares/pni/radio/xdot/: xdot.c xdot.h xdot_at_cmd.c xdot_at_cmd.h xdot_at_resp.c xdot_at_resp.h xdot_hex.c xdot_hex.h
  group Middlewares/PNI/Sensors
    ../Middlewares/PNI/Sensors/: adc_monitor.c mcp9808_l0xx.c
  group Middlewares/PNI/SENtralA2
    ../Middlewares/PNI/SENtral-A2/: ProgramEEPROM.c SENtralA2.c
  group Middlewares/PNI/system/crypto
    ../Middlewares/PNI/system/crypto/: crypto.h hmac.c md5.c
  group Middlewares/ST/SPI_Flash
    ../Middlewares/ST/SPI_Flash/: spi_flash.c
  group Middlewares/ST/STM32_BlueNRG/HCI
    ../Middlewares/ST/STM32_BlueNRG/SimpleBlueNRG_HCI/hci/: hci.c
  group Middlewares/ST/STM32_BlueNRG/HCI/controller
    ../Middlewares/ST/STM32_BlueNRG/SimpleBlueNRG_HCI/hci/controller/: bluenrg_gap_aci.c bluenrg_gatt_aci.c bluenrg_hal_aci.c bluenrg_l2cap_aci.c bluenrg_updater_aci.c bluenrg_utils.c
  group Middlewares/ST/STM32_BlueNRG/Interface
    ../Middlewares/ST/STM32_BlueNRG/Interface/: bluenrg_itf_template.c
  group Middlewares/ST/STM32_BlueNRG/Utils
    ../Middlewares/ST/STM32_BlueNRG/SimpleBlueNRG_HCI/utils/: ble_list.c gp_timer.c osal.c
